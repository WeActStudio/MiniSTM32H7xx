# Keil uVision project 11-ExtMem_Boot_USB.uvprojx, settings and files
target 11-ExtMem_Boot_USB (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: 11-ExtMem_Boot_USB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP\w25qxx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: hid_bootloader.c main.c gpio.c quadspi.c rtc.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/BSP/w25qxx
    ../Drivers/BSP/w25qxx/: w25qxx_qspi.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
software components: CMSIS:CORE 4.3.0
